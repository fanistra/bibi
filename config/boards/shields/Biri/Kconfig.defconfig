## config/boards/shields/Biri/Kconfig.defconfig
```kconfig
if SHIELD_BIRIBOARD

config ZMK_KEYBOARD_NAME
    default "BiriBoard"

CONFIG_BT_CTLR_TX_PWR_PLUS_8=y

endif
```
